DESCRIPTION = "libGLES for ZynqMP with Mali 400"

LICENSE = "Proprietary"

SRC_URI = " \
    https://www.xilinx.com/publications/products/tools/mali-400-userspace.tar \
    file://egl.pc \
    file://glesv1_cm.pc \
    file://glesv1.pc \
    file://glesv2.pc \
    file://wayland-egl.pc \
    file://gbm.pc \
    "
