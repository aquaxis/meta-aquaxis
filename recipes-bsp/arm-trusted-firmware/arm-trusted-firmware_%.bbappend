XILINX_RELEASE_VERSION = "v2018.2"
SRCREV = "93a69a5a3bc318027da4af5911124537f4907642"
